
RDEPENDS:${PN}-extras:append:pcomc660-ast2600 = " \
                                          libmctp \
                                         "

