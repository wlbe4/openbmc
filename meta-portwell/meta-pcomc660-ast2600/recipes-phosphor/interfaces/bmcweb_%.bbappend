EXTRA_OEMESON_append = " \
    -Dinsecure-tftp-update=enabled \
    -Dhttp-body-limit=128 \
"
